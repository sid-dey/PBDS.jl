Commit message: testing panda arm in different scenarios

File: urdf/panda/table_mug_panda_arm_hand_fingers_fixed.urdf (robot description, URDF)
Before this commit: robot panda, 16 links, 15 joints
Links:
- link mug: geometry visual mesh filename=package://franka_description/meshes/mug.dae
